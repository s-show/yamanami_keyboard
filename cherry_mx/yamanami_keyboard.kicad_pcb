# Repository s-show/yamanami_keyboard

## KiCad design cherry_mx/yamanami_keyboard.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: SOD123; D_SOD-123_custom
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20, H21, H22, H23, H24, H25, H26: MountingHole; MountingHole_2.2mm_M2
OL1, OL2: OLED; OLED_center_module_custom
R1, R2: 4.7k; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48: SW_Push; CherryMX_Hotswap_via_1U_custom
SW49: SW_DIP_x04; DIP_SWITCH_EDS102SZ-4P
U1, U2: RP2040-Zero; waveshare_rp2040-zero-Conthrough
trrs1, trrs2: TRRS; TRRS_PJ-320A

Connections:
+5V: OL1.3 (VCC), R1.1, U1.5V, trrs1.D
+5VA: OL2.3 (VCC), U2.5V, trrs2.D
Dip_pin1: SW49.1, U1.GP9
Dip_pin2: SW49.2, U1.GP10
Dip_pin3: SW49.3, U1.GP11
Dip_pin4: SW49.4, U1.GP12
GND: OL1.4 (GND), SW49.5, SW49.6, SW49.7, SW49.8, U1.GND, trrs1.A
GNDA: OL2.4 (GND), R2.1, U2.GND, trrs2.A
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: R1.2, U1.GP13
unnamed: R2.2, U2.GP13
SCL: OL1.2 (SCL), U1.GP15
SCL_r: OL2.1 (SDA), U2.GP12
SDA: OL1.1 (SDA), U1.GP14
SDA_r: OL2.2 (SCL), U2.GP11
col0: SW1.1, SW2.1, SW3.1, SW4.1, U1.GP0
col0_r: SW25.1, SW26.1, SW27.1, SW28.1, U2.GP14
col1: SW5.1, SW6.1, SW7.1, SW8.1, U1.GP1
col1_r: SW29.1, SW30.1, SW31.1, SW32.1, U2.GP15
col2: SW9.1, SW10.1, SW11.1, SW12.1, U1.GP2
col2_r: SW33.1, SW34.1, SW35.1, SW36.1, U2.GP26
col3: SW13.1, SW14.1, SW15.1, SW16.1, U1.GP3
col3_r: SW37.1, SW38.1, SW39.1, SW40.1, U2.GP27
col4: SW17.1, SW18.1, SW19.1, SW20.1, U1.GP4
col4_r: SW41.1, SW42.1, SW43.1, SW44.1, U2.GP28
col5: SW21.1, SW22.1, SW23.1, SW24.1, U1.GP5
col5_r: SW45.1, SW46.1, SW47.1, SW48.1, U2.GP29
row0: D1.1 (K), D5.1 (K), D9.1 (K), D13.1 (K), D17.1 (K), D21.1 (K), U1.GP29
row0_r: D25.1 (K), D29.1 (K), D33.1 (K), D37.1 (K), D41.1 (K), D45.1 (K), U2.GP0
row1: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), D18.1 (K), D22.1 (K), U1.GP28
row1_r: D26.1 (K), D30.1 (K), D34.1 (K), D38.1 (K), D42.1 (K), D46.1 (K), U2.GP1
row2: D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), D19.1 (K), D23.1 (K), U1.GP27
row2_r: D27.1 (K), D31.1 (K), D35.1 (K), D39.1 (K), D43.1 (K), D47.1 (K), U2.GP2
row3: D4.1 (K), D8.1 (K), D12.1 (K), D16.1 (K), D20.1 (K), D24.1 (K), U1.GP26
row3_r: D28.1 (K), D32.1 (K), D36.1 (K), D40.1 (K), D44.1 (K), D48.1 (K), U2.GP3
serial: U1.GP8, trrs1.C
serial_r: U2.GP9, trrs2.C

Notes on the sheet:
Left Hand
TRRS
MCU
POWER
DIP SWITCH
Key_Matrix
OLED
RIGHT HAND SCHEMATIC Power net changes: GND -> GNDA +5V -> +5VA to prevent kicad from complaining about no connections between halves
right Hand

Board: 2 copper layers, 294.2 x 109.7 mm, 131 parts (51 on the bottom side), 84 nets.

## KiCad design choc/yamanami_keyboard_choc.kicad_pcb

Parts:
Choc1, Choc2, Choc3, Choc4, Choc5, Choc6, Choc7, Choc8, Choc9, Choc10, Choc11, Choc12, Choc13, Choc14, Choc15, Choc16, Choc17, Choc18, Choc19, Choc20, Choc21, Choc22, Choc23, Choc24, Choc25, Choc26, Choc27, Choc28, Choc29, Choc30, Choc31, Choc32, Choc33, Choc34, Choc35, Choc36, Choc37, Choc38, Choc39, Choc40, Choc41, Choc42, Choc43, Choc44, Choc45, Choc46, Choc47, Choc48: Choc_V1; Kailh_socket_PG1350
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: SOD123; D3_TH_SMD_v2
J5, J10: MJ-4PP-9; MJ-4PP-9_1side
RST1: Reset_Switch; ResetSW_1side
RST2: RST_Switch; ResetSW_1side
U1, U2: ProMicro; ProMicro_v3

Connections:
DATA: J5.B, U1.2
DATA_R: J10.B, U2.2
GND: J5.C, RST1.2, U1.3, U1.4, U1.23
GNDA: J10.C, RST2.2, U2.3, U2.4, U2.23
unnamed: Choc1.2 (ROW), D1.2 (A)
unnamed: Choc2.2 (ROW), D2.2 (A)
unnamed: Choc3.2 (ROW), D3.2 (A)
unnamed: Choc4.2 (ROW), D4.2 (A)
unnamed: Choc5.2 (ROW), D5.2 (A)
unnamed: Choc6.2 (ROW), D6.2 (A)
unnamed: Choc7.2 (ROW), D7.2 (A)
unnamed: Choc8.2 (ROW), D8.2 (A)
unnamed: Choc9.2 (ROW), D9.2 (A)
unnamed: Choc10.2 (ROW), D10.2 (A)
unnamed: Choc11.2 (ROW), D11.2 (A)
unnamed: Choc12.2 (ROW), D12.2 (A)
unnamed: Choc13.2 (ROW), D13.2 (A)
unnamed: Choc14.2 (ROW), D14.2 (A)
unnamed: Choc15.2 (ROW), D15.2 (A)
unnamed: Choc16.2 (ROW), D16.2 (A)
unnamed: Choc17.2 (ROW), D17.2 (A)
unnamed: Choc18.2 (ROW), D18.2 (A)
unnamed: Choc19.2 (ROW), D19.2 (A)
unnamed: Choc20.2 (ROW), D20.2 (A)
unnamed: Choc21.2 (ROW), D21.2 (A)
unnamed: Choc22.2 (ROW), D22.2 (A)
unnamed: Choc23.2 (ROW), D23.2 (A)
unnamed: Choc24.2 (ROW), D24.2 (A)
unnamed: Choc25.2 (ROW), D25.2 (A)
unnamed: Choc26.2 (ROW), D26.2 (A)
unnamed: Choc27.2 (ROW), D27.2 (A)
unnamed: Choc28.2 (ROW), D28.2 (A)
unnamed: Choc29.2 (ROW), D29.2 (A)
unnamed: Choc30.2 (ROW), D30.2 (A)
unnamed: Choc31.2 (ROW), D31.2 (A)
unnamed: Choc32.2 (ROW), D32.2 (A)
unnamed: Choc33.2 (ROW), D33.2 (A)
unnamed: Choc34.2 (ROW), D34.2 (A)
unnamed: Choc35.2 (ROW), D35.2 (A)
unnamed: Choc36.2 (ROW), D36.2 (A)
unnamed: Choc37.2 (ROW), D37.2 (A)
unnamed: Choc38.2 (ROW), D38.2 (A)
unnamed: Choc39.2 (ROW), D39.2 (A)
unnamed: Choc40.2 (ROW), D40.2 (A)
unnamed: Choc41.2 (ROW), D41.2 (A)
unnamed: Choc42.2 (ROW), D42.2 (A)
unnamed: Choc43.2 (ROW), D43.2 (A)
unnamed: Choc44.2 (ROW), D44.2 (A)
unnamed: Choc45.2 (ROW), D45.2 (A)
unnamed: Choc46.2 (ROW), D46.2 (A)
unnamed: Choc47.2 (ROW), D47.2 (A)
unnamed: Choc48.2 (ROW), D48.2 (A)
RESET: RST1.1, U1.22
RESET_R: RST2.1, U2.22
VCC: J5.D, U1.21
VDD: J10.D, U2.21
col0: Choc1.1 (COL), Choc7.1 (COL), Choc13.1 (COL), Choc19.1 (COL), U1.13
col0_R: Choc25.1 (COL), Choc31.1 (COL), Choc37.1 (COL), Choc43.1 (COL), U2.12
col1: Choc2.1 (COL), Choc8.1 (COL), Choc14.1 (COL), Choc20.1 (COL), U1.15
col1_R: Choc26.1 (COL), Choc32.1 (COL), Choc38.1 (COL), Choc44.1 (COL), U2.11
col2: Choc3.1 (COL), Choc9.1 (COL), Choc15.1 (COL), Choc21.1 (COL), U1.16
col2_R: Choc27.1 (COL), Choc33.1 (COL), Choc39.1 (COL), Choc45.1 (COL), U2.10
col3: Choc4.1 (COL), Choc10.1 (COL), Choc16.1 (COL), Choc22.1 (COL), U1.17
col3_R: Choc28.1 (COL), Choc34.1 (COL), Choc40.1 (COL), Choc46.1 (COL), U2.9
col4: Choc5.1 (COL), Choc11.1 (COL), Choc17.1 (COL), Choc23.1 (COL), U1.18
col4_R: Choc29.1 (COL), Choc35.1 (COL), Choc41.1 (COL), Choc47.1 (COL), U2.8
col5: Choc6.1 (COL), Choc12.1 (COL), Choc18.1 (COL), Choc24.1 (COL), U1.19
col5_R: Choc30.1 (COL), Choc36.1 (COL), Choc42.1 (COL), Choc48.1 (COL), U2.7
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.20
row0_R: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U2.17
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.8
row1_R: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U2.16
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.9
row2_R: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U2.15
row3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.10
row3_R: D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U2.14

Notes on the sheet:
Left Hand
right Hand
MCU
Power_line
Connector
Key_Matrix
Mousebite
LED
Reset
RIGHT HAND SCHEMATIC Power net changes: VCC -> VDD GND -> GNDA to prevent kicad from complaining about no connections between halves

Board: 2 copper layers, 279.0 x 90.0 mm, 114 parts (48 on the bottom side), 76 nets.

Other parts of the board:
Ref**: Val**; M2_Threads_v2
Ref**#2, Ref**#3, Ref**#4, Ref**#5, Ref**#6, Ref**#7, Ref**#8, Ref**#9, Ref**#10, Ref**#11, Ref**#12: Val**; M2_Threads_v2

## KiCad design yamanami_keyboard.kicad_pcb

Parts:
C1, C2, C9, C10: 22pF; C_0603_1608Metric
C3, C4, C5, C11, C12, C13: 0.1uF; C_0603_1608Metric
C7, C15: 10uF; C_0603_1608Metric
C8, C18: 1uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: SOD123; D_SOD-123
D49, D50: D_Schottky_Small; D_SOD-123
F1, F2: 500mA; Fuse_1206_3216Metric
J1, J2, J3, J4, J11, J12, J13, J14: Breakaway_Tabs; breakaway-mousebites
J5, J8: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J6, J9: USB_C_Receptacle_USB2.0; HRO-TYPE-C-31-M-12-Assembly
J7, J10: Conn_01x04; PJ-3200B-4A-Assembly
J15, J16, J19, J20: Conn_01x01; Pin_D1.0mm_L10.0mm
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX43, MX44, MX45, MX46, MX47, MX48: MX-noLED; MXOnly-1U-Hotswap
R1, R4, R7, R8: 10k; R_0805_2012Metric
R2, R3, R9, R12: 5.1k; R_0805_2012Metric
R5, R6, R10, R11: 22; R_0805_2012Metric
SW1, SW2: SW_Push; SKQG-1155865
U1, U3: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
U2, U4: PRTR5V0U2X
Y1, Y2: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
D+: R5.1, U1.4 (D+)
D+_R: R10.1, U3.4 (D+)
D-: R6.1, U1.3 (D-)
D-_R: R11.1, U3.3 (D-)
DATA: J7.1, U1.20 (PD2)
DATA_R: J10.1, U3.20 (PD2)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C7.2, C8.2, J5.6, J6.1 (GND), J6.12 (GND), J6.13 (SHIELD), J7.2, R2.1, R3.2, R4.2, SW1.2, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), U2.1 (GND), Y1.2, Y1.4
GNDA: C9.1, C10.1, C11.2, C12.2, C13.2, C15.2, C18.2, J8.6, J9.1 (GND), J9.12 (GND), J9.13 (SHIELD), J10.2, R8.2, R9.1, R12.2, SW2.2, U3.5 (UGND), U3.15 (GND), U3.23 (GND), U3.35 (GND), U3.43 (GND), U4.1 (GND), Y2.2, Y2.4
MISO: J5.1, U1.11 (PB3)
MISO_R: J8.1, U3.11 (PB3)
MOSI: J5.4, U1.10 (PB2)
MOSI_R: J8.4, U3.10 (PB2)
unnamed: C8.1, U1.6 (UCAP)
unnamed: C18.1, U3.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D29.2 (A), MX29.2 (ROW)
unnamed: D30.2 (A), MX30.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D35.2 (A), MX35.2 (ROW)
unnamed: D36.2 (A), MX36.2 (ROW)
unnamed: D37.2 (A), MX37.2 (ROW)
unnamed: D38.2 (A), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D40.2 (A), MX40.2 (ROW)
unnamed: D41.2 (A), MX41.2 (ROW)
unnamed: D42.2 (A), MX42.2 (ROW)
unnamed: D43.2 (A), MX43.2 (ROW)
unnamed: D44.2 (A), MX44.2 (ROW)
unnamed: D45.2 (A), MX45.2 (ROW)
unnamed: D46.2 (A), MX46.2 (ROW)
unnamed: D47.2 (A), MX47.2 (ROW)
unnamed: D48.2 (A), MX48.2 (ROW)
unnamed: J6.4 (CC1), R2.2
unnamed: J6.5 (DN2), J6.7 (DN1), R6.2, U2.3 (IO2)
unnamed: J6.6 (DP1), J6.8 (DP2), R5.2, U2.2 (IO1)
unnamed: J6.10 (CC2), R3.1
unnamed: J9.4 (CC1), R9.2
unnamed: J9.5 (DN2), J9.7 (DN1), R11.2, U4.3 (IO2)
unnamed: J9.6 (DP1), J9.8 (DP2), R10.2, U4.2 (IO1)
unnamed: J9.10 (CC2), R12.1
unnamed: R4.1, U1.33 (~HWB~/PE2)
unnamed: R8.1, U3.33 (~HWB~/PE2)
unnamed: J15.1, U1.18 (PD0)
unnamed: J16.1, U1.19 (PD1)
unnamed: J19.1, U3.18 (PD0)
unnamed: J20.1, U3.19 (PD1)
RESET: J5.5, R1.2, SW1.1, U1.13 (~RESET)
RESET_R: J8.5, R7.2, SW2.1, U3.13 (~RESET)
SCK: J5.3, U1.9 (PB1)
SCK_R: J8.3, U3.9 (PB1)
VBUS: C7.1, D49.2 (A), F1.1, U1.7 (VBUS)
VCC: F1.2, J6.2 (VBUS), J6.11 (VBUS), U2.4 (VCC)
VDC: C15.1, D50.2 (A), F2.1, U3.7 (VBUS)
VDD: F2.2, J9.2 (VBUS), J9.11 (VBUS), U4.4 (VCC)
XTAL1: C1.2, U1.17 (XTAL1), Y1.3
XTAL1_R: C9.2, U3.17 (XTAL1), Y2.1
XTAL2: C2.2, U1.16 (XTAL2), Y1.1
XTAL2_R: C10.2, U3.16 (XTAL2), Y2.3
col0: MX1.1 (COL), MX7.1 (COL), MX13.1 (COL), MX19.1 (COL), U1.32 (PC7)
col0_R: MX25.1 (COL), MX31.1 (COL), MX37.1 (COL), MX43.1 (COL), U3.32 (PC7)
col5: MX6.1 (COL), MX12.1 (COL), MX18.1 (COL), MX24.1 (COL), U1.28 (PB4)
col5_R: MX30.1 (COL), MX36.1 (COL), MX42.1 (COL), MX48.1 (COL), U3.27 (PD7)
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.25 (PD4)
row2_R: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U3.22 (PD5)
row3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.22 (PD5)
row3_R: D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U3.25 (PD4)

Notes on the sheet:
Left Hand
right Hand
MCU
Power_line
USB, ESD Protection, Polyfuse
Connector
Key_Matrix
RIGHT HAND SCHEMATIC Power net changes: VCC -> VDD VBUS -> VDC GND -> GNDA +5V -> +5VA to prevent kicad from complaining about no connections between halves
Mousebite
Reserve_pin

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
Board: 2 copper layers, 262.5 x 106.5 mm, 148 parts (92 on the bottom side), 106 nets.

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
