# Repository s-show/yamanami_keyboard (continued)

## KiCad design arch_keyboard.kicad_pcb

Board: 2 copper layers, 127.1 x 87.9 mm, 71 parts (1 on the bottom side), 43 nets, no tracks yet.

Parts:
C1, C2: 22pF; C_0603_1608Metric
C3: 10uF; C_0603_1608Metric
C4: 1uF; C_0603_1608Metric
C5, C6, C7, C8: 0.1uF; C_0603_1608Metric
C9: 4.7uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: 1N4148; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0; HRO-TYPE-C-31-M-12
J2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J3: MJ-4PP-9; PJ-3200B-4A
R1, R6: 10k; R_0805_2012Metric
R2, R3: 5.1k; R_0805_2012Metric
R4, R5: 22; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25: SW_Push; MXOnly-1U-Hotswap
U1: PRTR5V0U2X
U2: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C3.2, C5.1, C6.1, C7.1, C8.1, C9.1, F1.1, J2.2, R1.1, U2.2, U2.14, U2.24, U2.34, U2.44
D+: R5.1, U1.2, U2.4
D-: R4.1, U1.3, U2.3
GND: C1.1, C2.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J2.6, R1.2, R2.1, R3.2, R6.2, SW1.2, U1.1, U1.4, U2.5, U2.15, U2.23, U2.35, U2.43, Y1.1, Y1.3
MISO: D4.1, D8.1, D12.1, D16.1, D20.1, D24.1, J2.1, SW2.1, SW3.1, SW4.1, SW5.1, U2.11, U2.28
MOSI: D3.1, D7.1, D11.1, D15.1, D19.1, D23.1, J2.4, U2.10
unnamed: C3.1, U2.7
unnamed: C4.1, U2.6
unnamed: D1.2, SW2.2
unnamed: D2.2, SW3.2
unnamed: D3.2, SW4.2
unnamed: D4.2, SW5.2
unnamed: D5.2, SW6.2
unnamed: D6.2, SW7.2
unnamed: D7.2, SW8.2
unnamed: D8.2, SW9.2
unnamed: D9.2, SW10.2
unnamed: D10.2, SW11.2
unnamed: D11.2, SW12.2
unnamed: D12.2, SW13.2
unnamed: D13.2, SW14.2
unnamed: D14.2, SW15.2
unnamed: D15.2, SW16.2
unnamed: D16.2, SW17.2
unnamed: D17.2, SW18.2
unnamed: D18.2, SW19.2
unnamed: D19.2, SW20.2
unnamed: D20.2, SW21.2
unnamed: D21.2, SW22.2
unnamed: D22.2, SW23.2
unnamed: D23.2, SW24.2
unnamed: D24.2, SW25.2
unnamed: R6.1, U2.33
RESET: J2.5, SW1.1, U2.13
SCK: D2.1, D6.1, D10.1, D14.1, D18.1, D22.1, J2.3, U2.9
XTAL1: C1.2, U2.17, Y1.2
XTAL2: C2.2, U2.16, Y1.4
col1: SW6.1, SW7.1, SW8.1, SW9.1, U2.29
col2: SW10.1, SW11.1, SW12.1, SW13.1, U2.30
col3: SW14.1, SW15.1, SW16.1, SW17.1, U2.12
col4: SW18.1, SW19.1, SW20.1, SW21.1, U2.31, U2.32
col5: SW22.1, SW23.1, SW24.1, SW25.1, U2.18
row0: D1.1, D5.1, D9.1, D13.1, D17.1, D21.1, U2.8

## Commit log

2020-11-24 backup.
2020-11-28 配線完了
2020-11-28 fixed symbol.
2020-11-29 配線の修正完了
2020-12-01 間違い修正
2020-12-06 シンボルライブラリとフットプリントライブラリの整理
2020-12-06 サブモジュール修正1
2020-12-06 サブモジュール修正2
2020-12-06 サブモジュール修正3
2020-12-06 サブモジュール修正4
2020-12-06 サブモジュール修正5
2020-12-06 サブモジュール修正6
2020-12-06 サブモジュール修正7
2020-12-06 サブモジュール修正9
2020-12-07 大改修前の保存
2021-01-09 左手の配線ほぼ完了
2021-05-15 Choc版作成
2021-05-15 プレート修正
2021-05-23 エラー解消
2021-05-23 Choc版完成
2021-05-23 シンボルとフットプリントのライブラリの参照先を修正
2021-05-23 サブモジュールの修正
2021-05-23 サブモジュール修正
2021-05-23 サブモジュール再修正
2021-10-16 Cherry MX版のライブラリ整理
2021-10-16 回路図の変更完了（第一段）
2023-03-06 途中経過の保存
2023-03-06 新型ケースの.stepファイルを追加
2024-10-31 CherryMX版作成 ver.0.1
